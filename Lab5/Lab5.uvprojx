# Keil uVision project Lab5.uvprojx, settings and files
target EK-TM4C1294XL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5 +hex
  AfterMake: fromelf.exe --bin Objects\Lab5.axf --output Objects\Lab5.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99
  c include: ..\TivaWare_C_Series-2.2.0.295
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c uart.c uart.h reles.c reles.h pwm.c pwm.h brilho.c brilho.h teclado.c teclado.h i2c.c i2c.h ssd1306.c ssd1306.h data.h display.c display.h protocolo.c protocolo.h startup_rvmdk.S
    ../TivaWare_C_Series-2.2.0.295/utils/: uartstdio.c
  group Documentation
    ./: readme.txt Comandos_Teste.txt
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.1.1
